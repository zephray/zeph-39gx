# Keil uVision project 39gs.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: S3C2410A Samsung
  cpu: IRAM(0x40000000-0x40001FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: 39gs
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe --bin --output ../obj/39gs.bin ../obj/39gs.axf
  c flags: Optim=2 wLevel=2
  c define: HP_ARM,MDK_ARM
  c include: ..\src\emu;..\src
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x8000000 size 0x38000
  memory RVCT9: RAM 0x40000000 size 0x1000
  group Source Group 1
    ../src/: main.c S3C2410A.s 2410addr.s option.s buzz.c misc.c font.c interrupt.c interface.c hwlcd.c key.c mmu.c 2410slib.s Retarget.c timer.c
