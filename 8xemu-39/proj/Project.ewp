# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: S3C2410A Samsung S3C2410A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\src\; ..\src\emu\
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: s3c2410.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group Emulator
    ../src/emu/: hardware.c ti8xemu.c z80.c
  group Startup
    ../src/: S3C2410A.s
  group User
    ../src/: 2410addr.s 2410slib.s buzz.c font.c hwlcd.c interface.c interrupt.c key.c main.c misc.c mmu.c timer.c
